# basic gumstix image

require gumstix-basic-image.bb

IMAGE_INSTALL += " \
    microwindows-snapshot \
    "


