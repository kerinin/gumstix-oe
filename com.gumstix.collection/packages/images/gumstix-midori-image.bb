# gumstix x11 image + midori

require gumstix-x11-image.bb

IMAGE_INSTALL += " \
    midori \
    "

